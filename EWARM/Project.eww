<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\AT24_Line_UC.ewp</path>
  </project>
  <batchBuild />
</workspace>
