# IAR project AT24_Line_UC.ewp, settings and files
configuration AT24_Line_UC (ARM, debug)
  General.OGChipSelectEditMenu: STM32F446VE ST STM32F446VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F446xx; _PROJECT_FOR_STM32_; _BOARD_CP24B_V1_1; _TEST_MODE_OFF_; COMPENSATE_DELAY_FE
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ../Task; ../MicroProg/LibMicroProg; ../MicroProg/headers; ../Drv; ../CommonFiles; ../Debug; ../dmc; ../dmc_lib; ../dmc_foc_aci; ../dmc_prm_mot; ../dmc_foc_pmsm
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: AT24_Line_UC.hex
  ILINK.IlinkOutputFile: AT24_Line_UC.out
  ILINK.IlinkIcfFile: stm32f446xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f446xx.s
  group Application/User
    ../Src/: freertos.c main.c stm32f4xx_hal_msp.c stm32f4xx_it_CP24.c stm32f4xx_it_CP24B.c
    ../Inc/: HeadFirmware.c
  group CommonFiles
    ../CommonFiles/: Const.h Filter.h GlobalVar.h
  group Debug
    ../Debug/: Logger.c measTime.c
  group dmc
    ../dmc/: CurVoltMeas_CP24.c CurVoltMeas_CP24B.c FailsControl.c MainControl_CP24.c MainControl_CP24B.c PwmControl_CP24.c PwmControl_CP24B.c Scalar_ORDINAR.c ScalarControl.c
    ../CommonFiles/: GlobalDefines.h
  group dmc_foc_pmsm
    ../dmc_foc_pmsm/: pmsm_antirollback.c pmsm_cross_rel_comp.c pmsm_cross_rel_comp_const.c pmsm_pi_reg_cur_const.c pmsm_pi_reg_spd_const.c pmsm_torq_comp.c PMSM_Vector_Control.c
  group dmc_for_aci
    ../dmc_foc_aci/: aci_cross_rel_comp.c aci_cross_rel_comp_const.c aci_fe.c aci_fe_const.c aci_pi_reg_cur_const.c aci_pi_reg_emf.c aci_pi_reg_emf_const.c aci_pi_reg_psir.c aci_pi_reg_spd_const.c aci_se.c aci_se_const.c aci_speed_lim_const.c ACI_Vector_Control.c
    ../dmc_lib/: pi_reg_cur.c
  group dmc_for_mot
    ../dmc_prm_mot/: ACI_prm_mot.c cntr_voltage.c LIB_PRM_MOT.c meas_lm_cur.c meas_rot_par_pow.c meas_rs.c PMSM_prm_mot.c ramp_cntl_gen.c rms_val_calc.c
  group dmc_lib
    ../dmc_lib/: anti_rollback.c bandstop_filter.c calc_var.c clarke.c deadtime_comp.c DRIVE_CONST.c DRIVE_WORDS.c FOC_params_copy.h iclarke.c ipark.c LIB_DMC.c linear_ramp.c load_loss.c loadContyChk.c minCurrCtrl.c park.c pi_reg_spd.c pi_reg_Torrent.c rs_trigger.c soft_cur_down.c speed_lim.c STFilter.c SvGen_dq.c UdcFiltr.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drv_CP24
    ../Drv/: DrvADC_CP24.c DrvADC_CP24B.c DrvBackupPowerCont_CP24B.c DrvCharge_CP24.c DrvCharge_CP24B.c DrvCompZPT_CP24.c DrvCompZPT_CP24B.c DrvDinDout_CP24x.c DrvDiscrT_CP24x.c DrvErrSWandSTO_CP24B.c DrvExtAnalogMK_CP24B.c DrvFan_CP24.c DrvFan_CP24B.c DrvLedStatus_CP24x.c DrvPWM_CP24x.c DrvRTC.c DrvSpi_CP24.c DrvSpi_CP24B.c DrvTypePow_CP24.c DrvTypePow_CP24B.c DrvUart_CP24.c DrvUart_CP24B.c FileRdWr_CP24.c FileRdWr_CP24B.c InputOutput.c Journal.c MTZ_Time.c TormSW_CP24x.c
    ../MicroProg/LibMicroProg/: Time_.c
  group MicroProg
    ../MicroProg/LibMicroProg/: CommonMicro.c crc.c LoadVar.c MakeOpis.c MakeOpis_at24.c MkMicro.c ModbusSlave.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Task
    ../Task/: Task20ms_CP24.c Task20ms_CP24B.c TaskDataFlash_CP24.c TaskDataFlash_CP24B.c TaskMicroProg.c TaskModbusSlave.c TaskStatusCP24.c
